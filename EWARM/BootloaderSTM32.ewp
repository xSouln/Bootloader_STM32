# IAR project BootloaderSTM32.ewp, settings and files
configuration BootloaderSTM32 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Sources; ../Sources/Usart; D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Drivers/STM32F1xx_HAL_Driver/Inc; D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Drivers/CMSIS/Device/ST/STM32F1xx/Include; D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Drivers/CMSIS/Include; C:\Users\Souln\Desktop\SDK\xLibMcrocontrollers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BootloaderSTM32.hex
  ILINK.IlinkOutputFile: BootloaderSTM32.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: adc.c dma.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Application/User/Sources
    ../Sources/: Bootloader.c Bootloader.h Ports.c Ports.h Responses.c Responses.h xFlash.c xFlash.h
  group Application/User/Usart
    ../Sources/Usart/: UsartX.c UsartX.h
  group Application/User/xLibMcrocontrollers
    ../../SDK/xLibMcrocontrollers/: xConverter.c xConverter.h xPort.h xRequest.h xResponse.c xResponse.h xRx.c xRx.h xTaskLine.c xTaskLine.h xThread.c xThread.h xTimers.c xTimers.h xTx.c xTx.h xType.h
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group Middlewares/USB_Device_Library
    D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    D:/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.1/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
